# Keil uVision project CM33.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: CM33
  AfterMake: fromelf.exe #L -c -d -e -s --output toFpga.lst
  AfterMake: fromelf.exe #L --bin -o toFpga.bin
  c flags: Optim=6 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\CM33_CMSIS;.\SA5Z50_DEVS;.\LIBS;.\USR
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group SA5Z50_DEVS
    ./SA5Z50_DEVS/: STAR_adc.c STAR_dma.c STAR_dualtimer.c STAR_gpio.c STAR_i2c.c STAR_mpu.c STAR_rcc.c STAR_retarget.c STAR_spi.c STAR_timer.c STAR_uart.c STAR_watchdog.c system_ARMCM33.c startup_ARMCM33.s
  group LIBS
    ./LIBS/: delay.c scd.c lcd_9488_drv.c touch_GT911_drv.c i2c_gpio.c
  group USR
    ./USR/: main.c NVIC_it.c scd_reg.c
